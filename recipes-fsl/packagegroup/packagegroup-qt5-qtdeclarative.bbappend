RDEPENDS_${PN} += " \
    qtdeclarative-qmlplugins \
    qtquickcontrols-qmlplugins \
    qtquick1 \
    qtquick1-qmlplugins \
    qtquick1-plugins \
    qtdeclarative-dev \
    qtdeclarative-mkspecs \
    qtdeclarative-plugins \
    qtdeclarative-qmlplugins \
    qtdeclarative-staticdev \
"
